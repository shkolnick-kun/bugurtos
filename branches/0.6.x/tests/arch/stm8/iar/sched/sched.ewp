# IAR project sched.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.PreInclude: ..\config.h
  ICCSTM8.CCIncludePath2: ..\..\..\..\..\arch\stm8\iar; ..
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sched.srec
  ILINK.IlinkOutputFile: sched.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../../../../main/sched/: main.c
    ../: test_func.c test_func.h
  group arch
    ../../../../../arch/stm8/iar/: bugurt_kernel.c bugurt_kernel.h bugurt_kernel_asm.S bugurt_proc_stack_init.c
  group kernel
    ../../../../../kernel/: crit_sec.c index.c ipc.c item.c kernel.c mutex.c pcounter.c pitem.c proc.c sched.c sem.c sig.c syscall.c timer.c xlist.c
